# Keil uVision project FC_k82F_Debug.uvprojx, settings and files
target FC_K82F_debug (6140000::V6.14::ARMCLANG)
  device: MK82FN256VLL15 NXP
  pack: NXP.MK82F25615_DFP.12.2.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: led_blinky.out
  c flags: Optim=2 OneElfS=1 v6Lang=6 v6LangP=4 wLevel=3
  c define: DEBUG, CPU_MK82FN256VLL15, FRDM_K82F, FREEDOM, SERIAL_PORT_TYPE_UART=1
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: .
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: MK82FN256xxx15_flash.scf
  link misc: --remove --keep=*(.FlashConfig)
  group source
    ../../src/: K82F_FlightController.c LAL.h RingBuffer.c RingBuffer.h FlightController_Debug.h
software components: CMSIS:CORE 5.4.0, Device:CMSIS:MK82F25615_header 1.0.0, Device:Startup:MK82F25615_startup 1.1.0
